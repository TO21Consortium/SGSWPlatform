# Keil uVision project MDK_Project.uvproj, settings and files
target Open152V-D (ARM-ADS)
  device: STM32L151RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SensorHUB_Firmware +hex
  c flags: Optim=1
  c define: STM32L15XXB_128K,USE_STDPERIPH_DRIVER
  c include: ..\inc;..\inc\driver_H;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx;..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group STM32L1xx_Driver
    ../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_gpio.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_wwdg.c stm32l1xx_exti.c stm32l1xx_rtc.c stm32l1xx_usart.c stm32l1xx_i2c.c stm32l1xx_tim.c
  group User
    ../src/: main.c system_stm32l1xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/arm/: startup_stm32l1xx_md.s
  group driver
    ../src/driver/: usart_1.c led.c i2c_slave.c i2c_master.c akm09916.c bmp280.c delay.c ltr553.c gpio.c icm20608.c
